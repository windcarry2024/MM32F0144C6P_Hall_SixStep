# Keil uVision project MM32F0144C6P.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0144C6P MindMotion
  pack: MindMotion.MM32F0140_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F0144C6P +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Firmware\CMSIS\IAR_Core;..\Firmware\CMSIS\KEIL_Core;..\Firmware\MM32F0140\HAL_Lib\Inc;..\Firmware\MM32F0140\Include;..\User;..\User\service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../Firmware/MM32F0140/Source/KEIL_StartAsm/: startup_mm32f0140_keil.s
  group Library
    ../Firmware/MM32F0140/HAL_Lib/Src/: hal_adc.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_misc.c hal_rcc.c hal_tim.c
  group Service
    ../User/service/: sysck.c sysck.h ctrl.c ctrl.h led.c led.h btn.c btn.h bldc.c bldc.h adc.c adc.h hall.c hall.h comm.c comm.h spd.c spd.h
  group User
    ../User/: main.c main.h mm32f0140_it.c mm32f0140_it.h
    ../Firmware/MM32F0140/Source/: system_mm32f0140.c
